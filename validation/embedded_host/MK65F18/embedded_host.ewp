# IAR project embedded_host.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 Freescale MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK65FN2M0VMI18; TOWER; TWR_K65F180M; USB_STACK_BM; DISABLE_WDOG=1; BL_EMBEDDED_HOST; CLOCK_SETUP=4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\src\platform\devices; ..\..\..\src\platform\devices\MK65F18; ..\..\..\src\platform\CMSIS\Include; ..\..\..\src\drivers; ..\..\..\src\drivers\common; ..\..\..\src\include; ..\..\..\src\startup; ..\..\..\src; src; ..\src; ..\src\disk; ..\src\shell; ..\src\image_program; ..\src\bm_usb; ..\..\..\src\usb\device; ..\..\..\src\usb\device\class; ..\..\..\src\usb\include; ..\..\..\src\usb\osa; ..\..\..\src\usb\utility\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: embedded_host.srec
  ILINK.IlinkOutputFile: embedded_host.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: ..\..\..\src\platform\devices\MK65F18\iar\MK65FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\src\platform\devices; ..\..\..\src\platform\devices\MK65F18; ..\..\..\src\platform\CMSIS\Include; ..\..\..\src\drivers; ..\..\..\src\drivers\common; ..\..\..\src\sdk_2.0\osc; ..\..\..\src\sdk_2.0\smc; ..\..\..\src\sdk_2.0\mcg; ..\..\..\src\include; ..\..\..\src\startup; ..\..\..\src; ..\src; ..\src\shell; ..\src\image_program; src; ..\src\disk; ..\..\..\src\usb\device; ..\..\..\src\usb\device\class; ..\..\..\src\usb\include; ..\..\..\src\usb\osa; ..\..\..\src\usb\utility\include; ..\..\..\src\usb\example\usb_device_msc_ramdisk\bm
  OBJCOPY.OOCOutputFile: offline_programmer.srec
  ILINK.IlinkOutputFile: embedded_host_TWR-K65F18.out
  group src/blsh
    ../../../src/blsh/: bllibc.c bllibc.h blsh.c blsh.h host_blsh_cmd.c host_blsh_cmd.h host_command.c host_command.h
  group src/board
    src/: board.c board.h pin_mux.c pin_mux.h
  group src/crc
    ../../../src/crc/src/: crc16.c
    ../../../src/crc/: crc16.h
  group src/drivers/crc
    ../../../src/drivers/crc/: fsl_crc.c
  group src/drivers/dspi
    ../../../src/drivers/dspi/: fsl_dspi.c
  group src/drivers/flash
    ../../../src/drivers/flash/: fsl_flash.c fsl_flash.h
  group src/drivers/flexcan
    ../../../src/drivers/flexcan/: fsl_flexcan.c
  group src/drivers/gpio
    ../../../src/drivers/gpio/: fsl_gpio.c
  group src/drivers/i2c
    ../../../src/drivers/i2c/: fsl_i2c.c
  group src/drivers/microseconds
    ../../../src/drivers/microseconds/: microseconds.h
    ../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/uart
    ../../../src/drivers/uart/: fsl_uart.c
  group src/osa
    ../../../src/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group src/sources
    ../src/: main.c
  group src/sources/disk
    ../src/disk/: disk.c disk.h fat_directory_entry.h usb_descriptor.c usb_descriptor.h usb_device_config.h usb_msd_disk.c usb_msd_disk.h
  group src/sources/host
    src/: host_hardware.c host_hardware.h
  group src/sources/image_program
    ../src/image_program/: binary_image.c binary_image.h executable_image.c executable_image.h intelhex_image.c intelhex_image.h SB_image.c SB_image.h srecord_image.c srecord_image.h
  group src/startup
    ../../../src/platform/devices/MK65F18/iar/: startup_MK65F18.s
    src/: system_MK65F18.c
  group src/usb/device/class
    ../../../src/usb/device/class/: usb_device_class.c usb_device_class.h
  group src/usb/device/class/msc
    ../../../src/usb/device/class/: usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group src/usb/device/include
    ../../../src/usb/device/: usb_device.h
  group src/usb/device/source
    ../../../src/usb/device/: usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h
  group src/usb/device/source/ehci
    ../../../src/usb/device/: usb_device_ehci.c usb_device_ehci.h
  group src/usb/device/source/khci
    ../../../src/usb/device/: usb_device_khci.c usb_device_khci.h
  group src/usb/include
    ../../../src/usb/include/: usb.h
  group src/utilities
    ../../../src/utilities/src/: bootloader_tree_stub.c fsl_assert.c fsl_rtos_abstraction.c
