<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MK65F18\embedded_host.ewp</path>
  </project>
  <batchBuild/>
</workspace>


