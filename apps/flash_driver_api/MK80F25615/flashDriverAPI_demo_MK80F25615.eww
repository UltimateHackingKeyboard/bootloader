<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TWR_K80F150M.ewp</path>
  </project>
  <batchBuild/>
</workspace>


