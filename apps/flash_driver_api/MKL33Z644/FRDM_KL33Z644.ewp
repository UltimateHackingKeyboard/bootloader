# IAR project FRDM_KL33Z644.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL33Z64xxx4 Freescale MKL33Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL33Z64VLH4; DEBUG; BL_CONFIG_LPUART; CLOCK_SETUP=0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: src; $PROJ_DIR$..\src; ..\..\..\src; ..\..\..\src\include; ..\..\..\src\platform\devices\MKL33Z644; ..\..\..\src\platform\CMSIS\Include; src\startup; ..\..\..\src\drivers; ..\..\..\src\drivers\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDM_KL33Z644.srec
  ILINK.IlinkOutputFile: FRDM_KL33Z644.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL33Z64VLH4; NDEBUG; BL_CONFIG_LPUART; CLOCK_SETUP=0
  ICCARM.CCOptLevel: 3
  group FRDM-KL33Z644
    src/: hardware_init_MKL33Z644.c
  group src/App
    ../src/: main.c
  group src/drivers/flash_api
    ../src/: fsl_flash.h fsl_flash_api_tree.c
  group src/drivers/lpuart
    ../../../src/drivers/lpuart/: fsl_lpuart.c
  group src/startup
    ../../../src/startup/: crt0.s startup.c
    src/startup/iar/: startup_MKL33Z644.s
    src/startup/: system_MKL33Z644.c
