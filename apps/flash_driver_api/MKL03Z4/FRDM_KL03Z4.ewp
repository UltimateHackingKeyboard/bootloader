# IAR project FRDM_KL03Z4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 Freescale MKL03Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL03Z32VFK4; DEBUG; BL_CONFIG_LPUART
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: src; $PROJ_DIR$..\src; ..\..\..\src; ..\..\..\src\include; ..\..\..\src\platform\devices\MKL03Z4; ..\..\..\src\platform\CMSIS\Include; src\startup; ..\..\..\src\drivers; ..\..\..\src\drivers\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDM_KL03Z4.srec
  ILINK.IlinkOutputFile: FRDM_KL03Z4.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL03Z32VFK4; NDEBUG; BL_CONFIG_LPUART
  ICCARM.CCOptLevel: 3
  group FRDM-KL03Z
    src/: hardware_init_MKL03Z4.c
  group link
    ../../../platform/devices/MKL03Z4/linker/iar/: MKL03Z32xxx4_flash.icf
  group src/App
    ../src/: main.c
  group src/drivers/flash_api
    ../src/: fsl_flash.h fsl_flash_api_tree.c
  group src/drivers/lpuart
    ../../../src/drivers/lpuart/: fsl_lpuart.c
  group src/startup
    ../../../src/startup/: crt0.s startup.c
    src/startup/iar/: startup_MKL03Z4.s
    src/startup/: system_MKL03Z4.c
