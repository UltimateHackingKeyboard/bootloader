# IAR project FRDM_K82F.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK82FN256xxx15 Freescale MK82FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MK82FN256VDC15; DEBUG; BL_CONFIG_LPUART
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: src; $PROJ_DIR$..\src; ..\..\..\src; ..\..\..\src\include; ..\..\..\src\platform\devices\MK82F25615; ..\..\..\src\platform\CMSIS\Include; src\startup; ..\..\..\src\drivers\; ..\..\..\src\drivers\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDM_K82F.srec
  ILINK.IlinkOutputFile: FlashDriverApi_FRDM_K82F.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  ICCARM.CCDefines: CPU_MK82FN256VDC15; NDEBUG; BL_CONFIG_LPUART
  ICCARM.CCIncludePath2: src; $PROJ_DIR$..\src; ..\..\..\src; ..\..\..\src\include; ..\..\..\src\platform\devices\MK82F25615; ..\..\..\src\platform\CMSIS\Include; src\startup; ..\..\..\src\drivers\; ..\..\..\src\drivers\common; ..\..\..\src\platform\CMSIS\Include; src\startup; ..\..\..\src\drivers\; ..\..\..\src\drivers\common
  ICCARM.CCOptLevel: 3
  group FRDM-K82F
    src/: hardware_init_MK82F25615.c
  group src/App
    ../src/: main.c
  group src/drivers/flash_api
    ../src/: fsl_flash.h fsl_flash_api_tree.c
  group src/drivers/lpuart
    ../../../src/drivers/lpuart/: fsl_lpuart.c
  group src/startup
    ../../../src/startup/: crt0.s startup.c
    src/startup/iar/: startup_MK82F25615.s
    src/startup/: system_MK82F256.c
