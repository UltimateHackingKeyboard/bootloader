# IAR project FRDM_KL82Z.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL82Z128xxx7 Freescale MKL82Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL82Z128VLH7; DEBUG; FRDM_KL82Z
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: src; src\startup; $PROJ_DIR$..\src; ..\..\..\src\platform\CMSIS\Include; ..\..\..\src\platform\devices\MKL82Z7; ..\..\..\src\platform\devices; ..\..\..\src\drivers\common; ..\..\..\src\drivers\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDM_K82F.srec
  ILINK.IlinkOutputFile: FlashDriverApi_FRDM_KL82Z.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL82Z128VLH7; NDEBUG; FRDM_KL82Z
  ICCARM.CCOptLevel: 3
  group FRDM-KL82Z
    src/: hardware_init_MKL82Z7.c
  group src/App
    ../src/: main.c
  group src/drivers/flash_api
    ../src/: fsl_flash.h fsl_flash_api_tree.c
  group src/drivers/lpuart
    ../../../src/drivers/lpuart/: fsl_lpuart.c
  group src/startup
    src/startup/iar/: startup_MKL82Z7.s
    src/startup/: system_MKL82Z7.c
