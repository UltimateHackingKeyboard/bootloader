<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FRDM_KL82Z.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TWR_KL82Z.ewp</path>
  </project>
  <batchBuild/>
</workspace>


