# IAR project FRDM_KL43Z4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL43Z256xxx4 Freescale MKL43Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL43Z256VLH4; DEBUG; BL_CONFIG_LPUART
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: src; $PROJ_DIR$..\src; ..\..\..\src; ..\..\..\src\include; ..\..\..\src\platform\devices\MKL43Z4; ..\..\..\src\platform\CMSIS\Include; src\startup; ..\..\..\src\drivers\; ..\..\..\src\drivers\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDM_KL43Z4.srec
  ILINK.IlinkOutputFile: FRDM_KL43Z4.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL43Z256VLH4; NDEBUG; BL_CONFIG_LPUART
  ICCARM.CCOptLevel: 3
  group FRDM-KL43Z
    src/: hardware_init_MKL43Z4.c
  group src/App
    ../src/: main.c
  group src/drivers/flash_api
    ../src/: fsl_flash.h fsl_flash_api_tree.c
  group src/drivers/lpuart
    ../../../src/drivers/lpuart/: fsl_lpuart.c
  group src/startup
    ../../../src/startup/: crt0.s startup.c
    src/startup/iar/: startup_MKL43Z4.s
    src/startup/: system_MKL43Z4.c
