<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>buspal_tower</project><configuration>Release</configuration></member><member><project>buspal_tower</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>buspal_tower</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>buspal_tower</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/iar/buspal_tower/buspal_tower.ewp</path></project></workspace>
