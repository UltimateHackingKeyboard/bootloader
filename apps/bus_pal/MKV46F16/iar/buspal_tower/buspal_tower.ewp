# IAR project buspal_tower.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F256xxx16 Freescale MKV46F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MKV46F256VLL16; DISABLE_WDOG=1; BUSPAL=1; IAR; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../src; ../../src; ../../../../../targets/MKV46F16/src; ../../../../../targets/MKV46F16/src/startup; ../../../../../src/platform/devices/MKV46F16; ../../../../../src/drivers/common; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/drivers; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: buspal_tower.elf
  ILINK.IlinkIcfFile: ../../../linker/iar/bus_pal.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV46F256VLL16; DISABLE_WDOG=1; BUSPAL=1; IAR; TOWER
  AARM.ADefines: NDEBUG
  group link
    ../../../linker/iar/: bus_pal.icf
  group src/startup
    ../../../../../src/startup/: boot.s crt0.s startup.c
    ../../../../../targets/MKV46F16/src/startup/iar/: startup_MKV46F16.s
    ../../../../../targets/MKV46F16/src/startup/: system_MKV46F16.c
  group kv46f16/bus_pal_TOWER-KV46F16/src
    ../../src/: bus_pal_hardware.c bus_pal_hardware.h
    ../../../src/: buspal_config.h command_handle.c command_handle.h main.c
  group kv46f16/utilities
    ../../../../../src/utilities/src/: bootloader_tree_stub.c fsl_assert.c fsl_rtos_abstraction.c
  group kv46f16/drivers/i2c
    ../../../../../src/drivers/i2c/: fsl_i2c.c fsl_i2c.h
  group kv46f16/drivers/dspi
    ../../../../../src/drivers/dspi/: fsl_dspi.c fsl_dspi.h
  group kv46f16/drivers/uart
    ../../../../../src/drivers/uart/: fsl_uart.c fsl_uart.h
  group kv46f16/drivers/flexcan
    ../../../../../src/drivers/flexcan/: fsl_flexcan.c fsl_flexcan.h
  group kv46f16/drivers/microseconds
    ../../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
    ../../../../../src/drivers/microseconds/: microseconds.h
