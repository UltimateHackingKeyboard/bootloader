# IAR project buspal_tower.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK65FN2M0xxx18 Freescale MK65FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MK65FN2M0VMI18; USB_STACK_BM; DISABLE_WDOG=1; TOWER; BUSPAL=1; BL_FEATURE_CAN=1; CLOCK_SETUP=4; CPU_IS_ARM_CORTEX_M4=1; IAR
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../src; ../../src; ../../../../../targets/MK65F18/src; ../../../../../targets/MK65F18/src/startup; ../../../../../src/platform/devices/MK65F18; ../../../../../src/drivers/common; ../../../../../src/bootloader; ../../../../../src/usb/include; ../../../../../src/usb/osa; ../../../../../src/usb/device; ../../../../../src/usb/device/class; ../../../../../src/bm_usb; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/drivers; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: buspal_tower.elf
  ILINK.IlinkIcfFile: ../../../../../src/platform/devices/MK65F18/iar/MK65FN2M0xxx18_flash.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK65FN2M0VMI18; USB_STACK_BM; DISABLE_WDOG=1; TOWER; BUSPAL=1; BL_FEATURE_CAN=1; CLOCK_SETUP=4; CPU_IS_ARM_CORTEX_M4=1; IAR
  AARM.ADefines: NDEBUG
  group link
    ../../../../../src/platform/devices/MK65F18/iar/: MK65FN2M0xxx18_flash.icf
  group src/startup
    ../../../../../targets/MK65F18/src/startup/iar/: startup_MK65F18.s
    ../../../../../targets/MK65F18/src/startup/: system_MK65F18.c
  group MK65F18/bus_pal_TOWER-MK65F18/src
    ../../src/: bus_pal_hardware.c bus_pal_hardware.h command.c command.h
    ../../../src/: buspal_config.h command_handle.c command_handle.h main.c
  group MK65F18/crc
    ../../../../../src/crc/src/: crc16.c crc32.c
    ../../../../../src/crc/: crc16.h crc32.h
  group MK65F18/utilities
    ../../../../../src/utilities/src/: bootloader_tree_stub.c fsl_assert.c fsl_rtos_abstraction.c
  group MK65F18/drivers/crc
    ../../../../../src/drivers/crc/: fsl_crc.c fsl_crc.h
  group MK65F18/drivers/i2c
    ../../../../../src/drivers/i2c/: fsl_i2c.c fsl_i2c.h
  group MK65F18/drivers/dspi
    ../../../../../src/drivers/dspi/: fsl_dspi.c fsl_dspi.h
  group MK65F18/drivers/uart
    ../../../../../src/drivers/uart/: fsl_uart.c fsl_uart.h
  group MK65F18/drivers/flexcan
    ../../../../../src/drivers/flexcan/: fsl_flexcan.c fsl_flexcan.h
  group MK65F18/drivers/microseconds
    ../../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
    ../../../../../src/drivers/microseconds/: microseconds.h
  group MK65F18/usb/bm_usb
    ../../../../../src/bm_usb/: bootloader_hid_report_ids.h composite.c composite.h fat_directory_entry.h hid_bootloader.c hid_bootloader.h msc_disk.c msc_disk.h usb_descriptor.c usb_descriptor.h
    ../../../../../targets/MK65F18/src/: usb_device_config.h
  group MK65F18/usb/device
    ../../../../../src/usb/device/: usb_device.h usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_ehci.c usb_device_ehci.h usb_device_khci.c usb_device_khci.h
  group MK65F18/usb/device/class
    ../../../../../src/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_hid.c usb_device_hid.h usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group MK65F18/usb/include
    ../../../../../src/usb/include/: usb.h
  group MK65F18/usb/osa
    ../../../../../src/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
