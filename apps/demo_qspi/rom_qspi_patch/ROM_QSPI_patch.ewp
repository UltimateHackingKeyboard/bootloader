# IAR project ROM_QSPI_patch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ROM_QSPI_patch.bin
  ILINK.IlinkOutputFile: ROM_QSPI_patch.out
  ILINK.IlinkProgramEntryLabel: rom_patch
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group application/include
    src/: hw_def.h qspi.h
  group application/src
    src/: rom_qspi_patch.c
