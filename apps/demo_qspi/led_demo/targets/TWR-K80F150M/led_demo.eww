<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>led_demo_pflash_0000</project><configuration>Release</configuration></member><member><project>led_demo_pflash_0000</project><configuration>Debug</configuration></member><member><project>led_demo_pflash_a000</project><configuration>Release</configuration></member><member><project>led_demo_pflash_a000</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_0000</project><configuration>Release</configuration></member><member><project>led_demo_qspi_0000</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_a000</project><configuration>Release</configuration></member><member><project>led_demo_qspi_a000</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_alias_rom</project><configuration>Release</configuration></member><member><project>led_demo_qspi_alias_rom</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_alias_a000</project><configuration>Release</configuration></member><member><project>led_demo_qspi_alias_a000</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_patch_rom</project><configuration>Release</configuration></member><member><project>led_demo_qspi_patch_rom</project><configuration>Debug</configuration></member><member><project>boot_to_qspi_alias_memory_rom</project><configuration>Release</configuration></member><member><project>boot_to_qspi_alias_memory_rom</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>led_demo_pflash_0000</project><configuration>Release</configuration></member><member><project>led_demo_pflash_a000</project><configuration>Release</configuration></member><member><project>led_demo_qspi_0000</project><configuration>Release</configuration></member><member><project>led_demo_qspi_a000</project><configuration>Release</configuration></member><member><project>led_demo_qspi_alias_rom</project><configuration>Release</configuration></member><member><project>led_demo_qspi_alias_a000</project><configuration>Release</configuration></member><member><project>led_demo_qspi_patch_rom</project><configuration>Release</configuration></member><member><project>boot_to_qspi_alias_memory_rom</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>led_demo_pflash_0000</project><configuration>Debug</configuration></member><member><project>led_demo_pflash_a000</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_0000</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_a000</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_alias_rom</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_alias_a000</project><configuration>Debug</configuration></member><member><project>led_demo_qspi_patch_rom</project><configuration>Debug</configuration></member><member><project>boot_to_qspi_alias_memory_rom</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/iar/led_demo_pflash_0000/led_demo_pflash_0000.ewp</path></project><project><path>$WS_DIR$/iar/led_demo_pflash_a000/led_demo_pflash_a000.ewp</path></project><project><path>$WS_DIR$/iar/led_demo_qspi_0000/led_demo_qspi_0000.ewp</path></project><project><path>$WS_DIR$/iar/led_demo_qspi_a000/led_demo_qspi_a000.ewp</path></project><project><path>$WS_DIR$/iar/led_demo_qspi_alias_rom/led_demo_qspi_alias_rom.ewp</path></project><project><path>$WS_DIR$/iar/led_demo_qspi_alias_a000/led_demo_qspi_alias_a000.ewp</path></project><project><path>$WS_DIR$/iar/led_demo_qspi_patch_rom/led_demo_qspi_patch_rom.ewp</path></project><project><path>$WS_DIR$/iar/boot_to_qspi_alias_memory_rom/boot_to_qspi_alias_memory_rom.ewp</path></project></workspace>
