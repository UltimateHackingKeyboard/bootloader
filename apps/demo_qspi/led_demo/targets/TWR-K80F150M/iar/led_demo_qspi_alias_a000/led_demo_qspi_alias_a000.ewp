# IAR project led_demo_qspi_alias_a000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MK80FN256VLQ15; CPU_IS_ARM_CORTEX_M4=1; IAR; TWR_K80F150M; BOOTLOADER_CONFIG; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../../src/platform/devices/MK80F25615; ../../../../src; ../../../../../../../src/include; ../../../../../../../src/platform; ../../../../../../../src/platform/devices; ../../../../../../../src/platform/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: led_demo_qspi_alias_a000.elf
  ILINK.IlinkIcfFile: ../../../common/linker/MK80F25615/iar/MK80FN256xxx15_qspi_alias_a000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VLQ15; CPU_IS_ARM_CORTEX_M4=1; IAR; TWR_K80F150M; BOOTLOADER_CONFIG; BL_TARGET_FLASH
  AARM.ADefines: NDEBUG
  group src/startup
    ../../../../devices/MK80F25615/startup/iar/: startup_MK80F25615_qspi.s
    ../../../../devices/MK80F25615/startup/: system_MK80F25615_qspi.c
    ../../../../../../../src/startup/: startup.c
  group src/application
    ../../../../src/: led_demo_qspi.c misc.c milliseconds_delay.c
  group link
    ../../../common/linker/MK80F25615/iar/: MK80FN256xxx15_qspi_alias_a000.icf
