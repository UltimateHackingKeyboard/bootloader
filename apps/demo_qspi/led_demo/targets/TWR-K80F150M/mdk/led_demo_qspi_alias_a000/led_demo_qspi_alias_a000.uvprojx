# Keil uVision project led_demo_qspi_alias_a000.uvprojx, settings and files
target led_demo_qspi_alias_a000 Debug (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_demo_qspi_alias_a000.elf
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MK80FN256VLQ15, CPU_IS_ARM_CORTEX_M4=1, TWR_K80F150M, BOOTLOADER_CONFIG, BL_TARGET_FLASH
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../src/platform/devices/MK80F25615;../../../../src;../../../../../../../src/include;../../../../../../../src/platform;../../../../../../../src/platform/devices;../../../../../../../src/platform/CMSIS/Include
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../common/linker/MK80F25615/arm/MK80FN256xxx15_qspi_alias_a000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group src:startup
    ../../../../devices/MK80F25615/startup/arm/: startup_MK80F25615_qspi.s
    ../../../../devices/MK80F25615/startup/: system_MK80F25615_qspi.c
    ../../../../../../../src/startup/: startup.c
  group src:application
    ../../../../src/: led_demo_qspi.c misc.c milliseconds_delay.c
  group link
    ../../../common/linker/MK80F25615/arm/: MK80FN256xxx15_qspi_alias_a000.scf
target led_demo_qspi_alias_a000 Release (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: as above
  output: led_demo_qspi_alias_a000.elf
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MK80FN256VLQ15, CPU_IS_ARM_CORTEX_M4=1, TWR_K80F150M, BOOTLOADER_CONFIG, BL_TARGET_FLASH
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: as above
