# Keil uVision project led_demo_qspi_patch_rom.uvprojx, settings and files
target led_demo_qspi_patch_rom Debug (ARM-ADS)
  device: MKL82Z128xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFA000,0x00018000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: led_demo_qspi_patch_rom.elf
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MKL81Z128VMC7, CPU_IS_ARM_CORTEX_M0P=1, TWR_POS_KL81, BOOTLOADER_CONFIG
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../../../src/platform/devices/MKL81Z7;../../../../src;../../../../../../../src/include;../../../../../../../src/platform;../../../../../../../src/platform/devices;../../../../../../../src/platform/CMSIS/Include
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffa000 size 0x18000
  scatter file: ../../../common/linker/MKL81Z7/arm/MKL81Z128xxx7_qspi_patch.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group src:startup
    ../../../../devices/MKL81Z7/startup/arm/: startup_MKL81Z7_qspi_patch.s
    ../../../../devices/MKL81Z7/startup/: system_MKL81Z7_qspi_patch.c
    ../../../../../../../src/startup/: startup.c
  group src:application
    ../../../../src/: led_demo_qspi.c misc.c milliseconds_delay.c
  group link
    ../../../common/linker/MKL81Z7/arm/: MKL81Z128xxx7_qspi_patch.scf
target led_demo_qspi_patch_rom Release (ARM-ADS)
  device: MKL82Z128xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: as above
  output: led_demo_qspi_patch_rom.elf
  AfterMake: fromelf.exe --m32combined  --output  "$L@L.srec"  "#L"
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MKL81Z128VMC7, CPU_IS_ARM_CORTEX_M0P=1, TWR_POS_KL81, BOOTLOADER_CONFIG
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: as above
