# IAR project led_demo_qspi_a000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL82Z128xxx7 Freescale MKL82Z128xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MKL81Z128VMC7; CPU_IS_ARM_CORTEX_M0P=1; IAR; TWR_POS_KL81; BOOTLOADER_CONFIG; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../../src/platform/devices/MKL81Z7; ../../../../src; ../../../../../../../src/include; ../../../../../../../src/platform; ../../../../../../../src/platform/devices; ../../../../../../../src/platform/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: led_demo_qspi_a000.elf
  ILINK.IlinkIcfFile: ../../../common/linker/MKL81Z7/iar/MKL81Z128xxx7_qspi_a000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL81Z128VMC7; CPU_IS_ARM_CORTEX_M0P=1; IAR; TWR_POS_KL81; BOOTLOADER_CONFIG; BL_TARGET_FLASH
  AARM.ADefines: NDEBUG
  group src/startup
    ../../../../devices/MKL81Z7/startup/iar/: startup_MKL81Z7_qspi.s
    ../../../../devices/MKL81Z7/startup/: system_MKL81Z7_qspi.c
    ../../../../../../../src/startup/: startup.c
  group src/application
    ../../../../src/: led_demo_qspi.c misc.c milliseconds_delay.c
  group link
    ../../../common/linker/MKL81Z7/iar/: MKL81Z128xxx7_qspi_a000.icf
