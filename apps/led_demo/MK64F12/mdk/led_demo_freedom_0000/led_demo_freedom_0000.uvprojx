# Keil uVision project led_demo_freedom_0000.uvprojx, settings and files
target led_demo_freedom_0000 Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_demo_freedom_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MK64FN1M0VMD12, CPU_IS_ARM_CORTEX_M4=1, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../targets/MK64F12/src;../../../../../targets/MK64F12/src/startup;../../../../../src/platform/devices/MK64F12;../../../src;../../../../../src/include;../../../../../src/platform;../../../../../src/platform/devices;../../../../../src/platform/CMSIS/Include;../../../../../src;../../../../../src/drivers;../../../../../src/startup;../../../../../src/drivers/uart
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../targets/common/linker/arm/MK64F12/MK64FN1M0xxx12_application_0x0000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../../../targets/common/linker/arm/MK64F12/: MK64FN1M0xxx12_application_0x0000.scf
  group src:startup
    ../../../../../targets/MK64F12/src/startup/arm/: startup_MK64F12.s
    ../../../../../targets/MK64F12/src/startup/: system_MK64F12.c
    ../../../../../src/startup/: startup.c
  group k64f12
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
  group k64f12-src
    ../../../../../src/utilities/src/: bootloader_tree_stub.c
target led_demo_freedom_0000 Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: as above
  output: led_demo_freedom_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, CPU_IS_ARM_CORTEX_M4=1, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: as above
