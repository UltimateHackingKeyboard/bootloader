# Keil uVision project led_demo_tower_a000.uvprojx, settings and files
target led_demo_tower_a000 Debug (ARM-ADS)
  device: MKV46F256xxx16 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: led_demo_tower_a000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MKV46F256VLL16, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../targets/MKV46F16/src;../../../../../targets/MKV46F16/src/startup;../../../../../src/platform/devices/MKV46F16;../../../src;../../../../../src/include;../../../../../src/platform;../../../../../src/platform/devices;../../../../../src/platform/CMSIS/Include;../../../../../src;../../../../../src/drivers;../../../../../src/startup;../../../../../src/drivers/uart
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../targets/common/linker/arm/MKV46F16/MKV46F256xxx16_application_0xa000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../../../targets/common/linker/arm/MKV46F16/: MKV46F256xxx16_application_0xa000.scf
  group src:startup
    ../../../../../targets/MKV46F16/src/startup/arm/: startup_MKV46F16.s
    ../../../../../targets/MKV46F16/src/startup/: system_MKV46F16.c
    ../../../../../src/startup/: startup.c
  group kv46f16
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
target led_demo_tower_a000 Release (ARM-ADS)
  device: MKV46F256xxx16 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: led_demo_tower_a000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MKV46F256VLL16, TOWER
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: as above
