# Keil uVision project led_demo_tower_0000.uvprojx, settings and files
target led_demo_tower_0000 Debug (ARM-ADS)
  device: MK22FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_demo_tower_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MK22FN256VDC12, CPU_IS_ARM_CORTEX_M4=1, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../targets/MK22F25612/src;../../../../../targets/MK22F25612/src/startup;../../../../../src/platform/devices/MK22F25612;../../../src;../../../../../src/include;../../../../../src/platform;../../../../../src/platform/devices;../../../../../src/platform/CMSIS/Include;../../../../../src;../../../../../src/drivers;../../../../../src/startup;../../../../../src/drivers/uart
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: ../../../../../targets/common/linker/arm/MK22F25612/MK22FN256xxx12_application_0x0000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group src:startup
    ../../../../../targets/MK22F25612/src/startup/arm/: startup_MK22F25612.s
    ../../../../../targets/MK22F25612/src/startup/: system_MK22F25612.c
    ../../../../../src/startup/: startup.c
  group MK22F25612
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
target led_demo_tower_0000 Release (ARM-ADS)
  device: MK22FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: as above
  output: led_demo_tower_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MK22FN256VDC12, CPU_IS_ARM_CORTEX_M4=1, TOWER
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  scatter file: as above
  link misc: as above
