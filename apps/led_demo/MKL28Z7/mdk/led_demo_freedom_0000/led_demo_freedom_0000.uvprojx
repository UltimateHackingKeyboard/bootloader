# Keil uVision project led_demo_freedom_0000.uvprojx, settings and files
target led_demo_freedom_0000 Debug (ARM-ADS)
  device: MKL28Z512xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x1FFF8000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: led_demo_freedom_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MKL28Z512VLH7, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../targets/MKL28Z7/src;../../../../../targets/MKL28Z7/src/startup;../../../../../src/platform/devices/MKL28Z7;../../../src;../../../../../src/drivers;../../../../../src/drivers/common;../../../../../src/include;../../../../../src/platform;../../../../../src/platform/devices;../../../../../src/platform/CMSIS/Include;../../../../../src;../../../../../src/startup;../../../../../src/drivers/uart
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: ../../../../../targets/common/linker/arm/MKL28Z7/MKL28Z512xxx7_application_0x0000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../../../targets/common/linker/arm/MKL28Z7/: MKL28Z512xxx7_application_0x0000.scf
  group src:startup
    ../../../../../targets/MKL28Z7/src/startup/arm/: startup_MKL28Z7.s
    ../../../../../targets/MKL28Z7/src/startup/: system_MKL28Z7.c
    ../../../../../src/startup/: startup.c
  group MKL28Z7
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
  group MKL28Z7-src-drivers-wdog32
    ../../../../../src/drivers/wdog32/: fsl_wdog32.c
target led_demo_freedom_0000 Release (ARM-ADS)
  device: MKL28Z512xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: as above
  output: led_demo_freedom_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MKL28Z512VLH7, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: as above
  link misc: as above
