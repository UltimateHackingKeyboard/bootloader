# IAR project led_demo_freedom_0000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL28Z512xxx7 Freescale MKL28Z512xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MKL28Z512VLH7; CPU_IS_ARM_CORTEX_M0P=1; IAR; FREEDOM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../targets/MKL28Z7/src; ../../../../../targets/MKL28Z7/src/startup; ../../../../../src/platform/devices/MKL28Z7; ../../../src; ../../../../../src/drivers; ../../../../../src/drivers/common; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_HAS_BOOTLOADER_CONFIG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: led_demo_freedom_0000.elf
  ILINK.IlinkIcfFile: ../../../../../targets/common/linker/iar/MKL28Z7/MKL28Z512xxx7_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL28Z512VLH7; CPU_IS_ARM_CORTEX_M0P=1; IAR; FREEDOM
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  group link
    ../../../../../targets/common/linker/iar/MKL28Z7/: MKL28Z512xxx7_application_0x0000.icf
  group src/startup
    ../../../../../src/startup/: crt0.s startup.c
    ../../../../../targets/MKL28Z7/src/startup/iar/: startup_MKL28Z7.s
    ../../../../../targets/MKL28Z7/src/startup/: system_MKL28Z7.c
  group MKL28Z7
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
  group MKL28Z7/src/drivers/wdog32
    ../../../../../src/drivers/wdog32/: fsl_wdog32.c
