# Keil uVision project led_demo_freedom_8000.uvprojx, settings and files
target led_demo_freedom_8000 Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: led_demo_freedom_8000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MKL25Z128VLK4, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../targets/MKL25Z4/src;../../../../../targets/MKL25Z4/src/startup;../../../../../src/platform/devices/MKL25Z4;../../../src;../../../../../src/include;../../../../../src/platform;../../../../../src/platform/devices;../../../../../src/platform/CMSIS/Include;../../../../../src;../../../../../src/drivers;../../../../../src/startup;../../../../../src/drivers/uart
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../../../targets/common/linker/arm/MKL25Z4/MKL25Z128xxx4_application_0x8000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../../../targets/common/linker/arm/MKL25Z4/: MKL25Z128xxx4_application_0x8000.scf
  group src:startup
    ../../../../../targets/MKL25Z4/src/startup/arm/: startup_MKL25Z4.s
    ../../../../../targets/MKL25Z4/src/startup/: system_MKL25Z4.c
    ../../../../../src/startup/: startup.c
  group MKL25Z4
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
  group MKL25Z4-src
    ../../../../../src/utilities/src/: bootloader_tree_stub.c
target led_demo_freedom_8000 Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: as above
  output: led_demo_freedom_8000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MKL25Z128VLK4, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: as above
  link misc: as above
