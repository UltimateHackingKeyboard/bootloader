# Keil uVision project led_demo_tower_a000.uvprojx, settings and files
target led_demo_tower_a000 Debug (ARM-ADS)
  device: MKV58F1M0xxx22 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.5.0
  cpu: IROM(0x10000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x2F000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: led_demo_tower_a000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MKV58F1M0VLQ22, CPU_IS_ARM_CORTEX_M7=1, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../targets/MKV58F22/src;../../../../../targets/MKV58F22/src/startup;../../../../../src/platform/devices/MKV58F22;../../../src;../../../../../src/include;../../../../../src/platform;../../../../../src/platform/devices;../../../../../src/platform/CMSIS/Include;../../../../../src;../../../../../src/drivers;../../../../../src/startup;../../../../../src/drivers/uart
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x2f000000 size 0x10000
  scatter file: ../../../../../targets/common/linker/arm/MKV58F22/MKV58F1M0xxx22_application_0x1000a000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../../../targets/common/linker/arm/MKV58F22/: MKV58F1M0xxx22_application_0x1000a000.scf
  group src:startup
    ../../../../../targets/MKV58F22/src/startup/arm/: startup_MKV58F22.s
    ../../../../../targets/MKV58F22/src/startup/: system_MKV58F22.c
    ../../../../../src/startup/: startup.c
  group kv58f22
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
target led_demo_tower_a000 Release (ARM-ADS)
  device: MKV58F1M0xxx22 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.5.0
  cpu: as above
  output: led_demo_tower_a000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MKV58F1M0VLQ22, CPU_IS_ARM_CORTEX_M7=1, TOWER
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x2f000000 size 0x10000
  scatter file: as above
  link misc: as above
