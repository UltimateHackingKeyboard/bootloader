# IAR project led_demo_tower_a000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK02FN128xxx10 Freescale MK02FN128xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MK02FN128VLH10; IAR; TOWER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../targets/MK02F12810/src; ../../../../../targets/MK02F12810/src/startup; ../../../../../src/platform/devices/MK02F12810; ../../../src; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/drivers; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_HAS_BOOTLOADER_CONFIG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: led_demo_tower_a000.elf
  ILINK.IlinkIcfFile: ../../../../../targets/common/linker/iar/MK02F12810/K02F128xxx10_application_0xa000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK02FN128VLH10; IAR; TOWER
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  group link
    ../../../../../targets/common/linker/iar/MK02F12810/: K02F128xxx10_application_0xa000.icf
  group src/startup
    ../../../../../src/startup/: crt0.s startup.c
    ../../../../../targets/MK02F12810/src/startup/iar/: startup_MK02F12810.s
    ../../../../../targets/MK02F12810/src/startup/: system_MK02F12810.c
  group MK02F12810
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
