# Keil uVision project led_demo_freedom_0000.uvprojx, settings and files
target led_demo_freedom_0000 Debug (ARM-ADS)
  device: MK82FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led_demo_freedom_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MK82FN256VLL15, CPU_IS_ARM_CORTEX_M4=1, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../targets/MK82F25615/src;../../../../../targets/MK82F25615/src/startup;../../../../../src/platform/devices/MK82F25615;../../../src;../../../../../src/include;../../../../../src/platform;../../../../../src/platform/devices;../../../../../src/platform/CMSIS/Include;../../../../../src;../../../../../src/drivers;../../../../../src/startup;../../../../../src/drivers/uart
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../targets/common/linker/arm/MK82F25615/MK82FN256xxx15_application_0x0000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../../../targets/common/linker/arm/MK82F25615/: MK82FN256xxx15_application_0x0000.scf
  group src:startup
    ../../../../../targets/MK82F25615/src/startup/arm/: startup_MK82F25615.s
    ../../../../../targets/MK82F25615/src/startup/: system_MK82F256.c
    ../../../../../src/startup/: startup.c
  group MK82F25615
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
  group MK82F25615-src
    ../../../../../src/utilities/src/: bootloader_tree_stub.c
target led_demo_freedom_0000 Release (ARM-ADS)
  device: MK82FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: as above
  output: led_demo_freedom_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MK82FN256VLL15, CPU_IS_ARM_CORTEX_M4=1, FREEDOM
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: as above
