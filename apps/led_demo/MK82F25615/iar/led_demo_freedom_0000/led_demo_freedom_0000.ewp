# IAR project led_demo_freedom_0000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK82FN256xxx15 Freescale MK82FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MK82FN256VLL15; CPU_IS_ARM_CORTEX_M4=1; IAR; FREEDOM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../targets/MK82F25615/src; ../../../../../targets/MK82F25615/src/startup; ../../../../../src/platform/devices/MK82F25615; ../../../src; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/drivers; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_HAS_BOOTLOADER_CONFIG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: led_demo_freedom_0000.elf
  ILINK.IlinkIcfFile: ../../../../../targets/common/linker/iar/MK82F25615/MK82FN256xxx15_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK82FN256VLL15; CPU_IS_ARM_CORTEX_M4=1; IAR; FREEDOM
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  group link
    ../../../../../targets/common/linker/iar/MK82F25615/: MK82FN256xxx15_application_0x0000.icf
  group src/startup
    ../../../../../src/startup/: crt0.s startup.c
    ../../../../../targets/MK82F25615/src/startup/iar/: startup_MK82F256.s
    ../../../../../targets/MK82F25615/src/startup/: system_MK82F256.c
  group MK82F25615
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
  group MK82F25615/src
    ../../../../../src/utilities/src/: bootloader_tree_stub.c
