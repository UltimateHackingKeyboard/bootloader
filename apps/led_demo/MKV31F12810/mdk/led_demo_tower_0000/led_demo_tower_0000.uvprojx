# Keil uVision project led_demo_tower_0000.uvprojx, settings and files
target led_demo_tower_0000 Debug (ARM-ADS)
  device: MKV31F128xxx10 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: led_demo_tower_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, DEBUG, CPU_MKV31F128VLL10, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../targets/MKV31F12810/src;../../../../../targets/MKV31F12810/src/startup;../../../../../src/platform/devices/MKV31F12810;../../../src;../../../../../src/include;../../../../../src/platform;../../../../../src/platform/devices;../../../../../src/platform/CMSIS/Include;../../../../../src;../../../../../src/drivers;../../../../../src/startup;../../../../../src/drivers/uart
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../targets/common/linker/arm/MKV31F12810/MKV31F128xxx10_application_0x0000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../../../targets/common/linker/arm/MKV31F12810/: MKV31F128xxx10_application_0x0000.scf
  group src:startup
    ../../../../../targets/MKV31F12810/src/startup/arm/: startup_MKV31F12810.s
    ../../../../../targets/MKV31F12810/src/startup/: system_MKV31F12810.c
    ../../../../../src/startup/: startup.c
  group MKV31F12810
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
target led_demo_tower_0000 Release (ARM-ADS)
  device: MKV31F128xxx10 Freescale
  pack: Keil.Kinetis_K20_DFP.1.1.0
  cpu: as above
  output: led_demo_tower_0000.elf
  c flags: Optim=4 wLevel=2
  c define: NDEBUG, CPU_MKV31F128VLL10, TOWER
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=1
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: as above
