# IAR project led_demo_tower_0000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F256xxx12 Freescale MKV31F256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MKV31F256VLL12; IAR; TOWER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../targets/MKV31F25612/src; ../../../../../targets/MKV31F25612/src/startup; ../../../../../src/platform/devices/MKV31F25612; ../../../src; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/drivers; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_HAS_BOOTLOADER_CONFIG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: led_demo_tower_0000.elf
  ILINK.IlinkIcfFile: ../../../../../targets/common/linker/iar/MKV31F25612/KV31F256xxx12_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F256VLL12; IAR; TOWER
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  group link
    ../../../../../targets/common/linker/iar/MKV31F25612/: KV31F256xxx12_application_0x0000.icf
  group src/startup
    ../../../../../src/startup/: crt0.s startup.c
    ../../../../../targets/MKV31F25612/src/startup/iar/: startup_MKV31F25612.s
    ../../../../../targets/MKV31F25612/src/startup/: system_MKV31F25612.c
  group MKV31F25612
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
