<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>led_demo_tower_0000</project><configuration>Debug</configuration></member><member><project>led_demo_tower_0000</project><configuration>Release</configuration></member><member><project>led_demo_tower_a000</project><configuration>Debug</configuration></member><member><project>led_demo_tower_a000</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>led_demo_tower_0000</project><configuration>Debug</configuration></member><member><project>led_demo_tower_a000</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>led_demo_tower_0000</project><configuration>Release</configuration></member><member><project>led_demo_tower_a000</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/iar/led_demo_tower_0000/led_demo_tower_0000.ewp</path></project><project><path>$WS_DIR$/iar/led_demo_tower_a000/led_demo_tower_a000.ewp</path></project></workspace>
