# IAR project led_demo_tower_a000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN1M0xxx12 Freescale MK24FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MK24FN256VDC12; CPU_IS_ARM_CORTEX_M4=1; IAR; TOWER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../targets/MK24F25612/src; ../../../../../targets/MK24F25612/src/startup; ../../../../../src/platform/devices/MK24F25612; ../../../src; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/drivers; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_HAS_BOOTLOADER_CONFIG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: led_demo_tower_a000.elf
  ILINK.IlinkIcfFile: ../../../../../targets/common/linker/iar/MK24F25612/K24FN256xxx12_application_0xa000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; CPU_IS_ARM_CORTEX_M4=1; IAR; TOWER
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  group link
    ../../../../../targets/common/linker/iar/MK24F25612/: K24FN256xxx12_application_0xa000.icf
  group src/startup
    ../../../../../src/startup/: crt0.s startup.c
    ../../../../../targets/MK24F25612/src/startup/iar/: startup_MK24F25612.s
    ../../../../../targets/MK24F25612/src/startup/: system_MK24F25612.c
  group MK24F25612
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
