# Keil uVision project flashloader_loader.uvprojx, settings and files
target flashloader_loader Debug (ARM-ADS)
  device: MK82FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flashloader_loader.elf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: DEBUG, USB_STACK_BM, CPU_MK82FN256VLQ15, CPU_IS_ARM_CORTEX_M4=1, BL_TARGET_FLASH
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66,1296,186,170
  c include: ../flashloader/output;../../src;../../src/startup;../../../../src/platform/devices/MK82F25615;../../../../src/include;../../../../src/platform/devices;../../../../src/platform/CMSIS/Include;../../../../src;../../../../src/drivers;../../../../src/startup;../../../../src/drivers/common
  asm define: BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../common/linker/arm/MK82F25615/MK82FN256xxx15_flashloader_loader.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x200"
  group link
    ../../../common/linker/arm/MK82F25615/: MK82FN256xxx15_flashloader_loader.scf
  group src:startup
    ../../src/startup/arm/: startup_MK82F25615.s
    ../../src/startup/: system_MK82F256.c
    ../../../../src/startup/: startup.c
  group MK82F256
    ../../src/: bootloader_config.h
  group src:bootloader
    ../../../../src/bootloader/: flashloader_image.h
  group src:bootloader:src
    ../../../../src/bootloader/src/: bl_flashloader.c
  group src:include
    ../../../../src/include/: bootloader_common.h
target flashloader_loader Release (ARM-ADS)
  device: MK82FN256xxx15 Freescale
  pack: Keil.Kinetis_K80_DFP.1.0.0
  cpu: as above
  output: flashloader_loader.elf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USB_STACK_BM, CPU_MK82FN256VLQ15, CPU_IS_ARM_CORTEX_M4=1, BL_TARGET_FLASH
  c misc: as above
  c include: as above
  asm define: BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: as above
  link misc: as above
