# IAR project flashloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK82FN256xxx15 Freescale MK82FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; NDEBUG; USB_STACK_BM; CPU_MK82FN256VLQ15; CPU_IS_ARM_CORTEX_M4=1; IAR; BL_TARGET_RAM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../src; ../../src/startup; ../../../../src/platform/devices/MK82F25615; ../../../../src/autobaud; ../../../../src/usb/include; ../../../../src/usb/osa; ../../../../src/usb/device; ../../../../src/usb/device/class; ../../../../src/bm_usb; ../../../../src/include; ../../../../src/platform; ../../../../src/platform/devices; ../../../../src/platform/CMSIS/Include; ../../../../src; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  postbuild: cmd /c ..\..\..\..\bin\create_flashloader_image.bat $PROJ_DIR$ Debug
  ILINK.IlinkOutputFile: flashloader.elf
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MK82F25615/MK82FN256xxx15_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USB_STACK_BM; CPU_MK82FN256VLQ15; CPU_IS_ARM_CORTEX_M4=1; IAR; BL_TARGET_RAM
  AARM.ADefines: NDEBUG
  postbuild: cmd /c ..\..\..\..\bin\create_flashloader_image.bat $PROJ_DIR$ Release
  group link
    ../../../common/linker/iar/MK82F25615/: MK82FN256xxx15_ram_flashloader.icf
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../src/startup/iar/: startup_MK82F256.s
    ../../src/startup/: system_MK82F256.c
  group src/autobaud
    ../../../../src/autobaud/: autobaud.h
  group src/autobaud/src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src/bootloader
    ../../../../src/bootloader/: bl_app_crc_check.h bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: lpuart_peripheral_interface.c dspi_peripheral_interface.c i2c_peripheral_interface.c usb_hid_msc_peripheral_interface.c bl_app_crc_check.c bl_misc.c bl_reliable_update.c bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c
  group src/drivers/crc
    ../../../../src/drivers/crc/: fsl_crc.c
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_pit.c
  group src/drivers/lpuart
    ../../../../src/drivers/lpuart/: fsl_lpuart.c
  group src/drivers/i2c/src
    ../../../../src/drivers/i2c/: fsl_i2c.c
  group src/drivers/dspi
    ../../../../src/drivers/dspi/: fsl_dspi.c
  group src/drivers/qspi
    ../../../../src/drivers/qspi/: qspi.h
  group src/drivers/qspi/src
    ../../../../src/drivers/qspi/src/: qspi.c
  group src/drivers/ltc
    ../../../../src/drivers/ltc/: ltc.h
  group src/drivers/ltc/src
    ../../../../src/drivers/ltc/src/: ltc_aes_functions.c
  group src/drivers/otfad
    ../../../../src/drivers/otfad/: fsl_otfad_driver.h
  group src/drivers/otfad/src
    ../../../../src/drivers/otfad/src/: fsl_otfad_driver.c
    ../../../../src/drivers/otfad/hal/: fsl_otfad_hal.c
  group src/drivers/mmcau
    ../../../../src/drivers/mmcau/: mmcau.h
  group src/drivers/mmcau/src
    ../../../../src/drivers/mmcau/src/: mmcau_aes_functions.c
  group src/drivers/port
    ../../../../src/drivers/port/: fsl_port.h
  group src/drivers/gpio
    ../../../../src/drivers/gpio/: fsl_gpio.c
  group src/drivers/smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group src/drivers/flash
    ../../../../src/drivers/flash/: fsl_flash.c fsl_flash.h
  group src/usb/device
    ../../../../src/usb/device/: usb_device.h usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_khci.c usb_device_khci.h
  group src/usb/device/calss
    ../../../../src/usb/device/class/: usb_device_class.h usb_device_class.c usb_device_hid.h usb_device_hid.c usb_device_msc.h usb_device_msc.c usb_device_msc_ufi.h usb_device_msc_ufi.c
  group src/usb/include
    ../../../../src/usb/include/: usb.h
  group src/usb/osa
    ../../../../src/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group src/usb/bm_composite
    ../../../../src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c msc_disk.h msc_disk.c usb_descriptor.h usb_descriptor.c
    ../../src/: usb_device_config.h
  group src/memory
    ../../../../src/memory/: memory.h
  group src/memory/src
    ../../../../src/memory/src/: qspi_memory.c qspi_memory.h sram_init_cm4.c memory.c device_memory.h device_memory.c flash_memory.h flash_memory.c normal_memory.h normal_memory.c pattern_fill.h pattern_fill.s
  group src/security
    ../../../../src/security/: aes_security.h aes128_key_wrap_unwrap.h cbc_mac.h
  group src/security/src
    ../../../../src/security/src/: aes_security.c aes128_key_wrap_unwrap.c cbc_mac.c
  group src/crc
    ../../../../src/crc/: crc16.h crc32.h
  group src/crc/src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src/include
    ../../../../src/include/: bootloader_common.h
  group src/packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src/packet/src
    ../../../../src/packet/src/: serial_packet.c
  group src/property
    ../../../../src/property/: property.h
  group src/property/src
    ../../../../src/property/src/: property.c
  group src/sbloader
    ../../../../src/sbloader/: sbloader.h
  group src/sbloader/src
    ../../../../src/sbloader/src/: sbloader.c
  group src/utilities
    ../../../../src/utilities/: fsl_rtos_abstraction.h
  group src/utilities/src
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
  group MK82F256
    ../../src/: bootloader_config.h clock_config_MK82F256.c hardware_init_MK82F256.c memory_map_MK82F256.c external_memory_property_map_MK82F256.c peripherals_MK82F256.c peripherals_pinmux.h target_config.h
    ../../../common/src/: pinmux_utility_common.c bl_dspi_irq_config_common.c bl_i2c_irq_config_common.c bl_lpuart_irq_config_common.c
