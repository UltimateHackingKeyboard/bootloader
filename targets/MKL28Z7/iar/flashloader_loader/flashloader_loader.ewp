# IAR project flashloader_loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL28Z512xxx7 Freescale MKL28Z512xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; USB_STACK_BM; CPU_MKL28Z512VLH7; CPU_IS_ARM_CORTEX_M0P=1; IAR; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../flashloader/output; ../../src; ../../src/startup; ../../../../src/platform/devices/MKL28Z7; ../../../../src/include; ../../../../src/platform/devices; ../../../../src/platform/CMSIS/Include; ../../../../src; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LITE_FOOTPRINT
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: flashloader_loader.elf
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MKL28Z7/MKL28Z512xxx7_flashloader_loader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USB_STACK_BM; CPU_MKL28Z512VLH7; CPU_IS_ARM_CORTEX_M0P=1; IAR; BL_TARGET_FLASH
  group link
    ../../../common/linker/iar/MKL28Z7/: MKL28Z512xxx7_flashloader_loader.icf
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../src/startup/iar/: startup_MKL28Z7.s
    ../../src/startup/: system_MKL28Z7.c
  group src/drivers/wdog32
    ../../../../src/drivers/wdog32/: fsl_wdog32.c
  group src/bootloader
    ../../../../src/bootloader/: flashloader_image.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: bl_flashloader.c
  group src/include
    ../../../../src/include/: bootloader_common.h
  group MKL28Z7
    ../../src/: bootloader_config.h
