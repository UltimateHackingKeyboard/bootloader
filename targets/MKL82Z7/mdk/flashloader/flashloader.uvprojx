# Keil uVision project flashloader.uvprojx, settings and files
target flashloader Debug (ARM-ADS)
  device: MKL82Z128xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFA000,0x00018000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: flashloader.elf
  AfterMake: fromelf  --bincombined output\debug\flashloader.elf --output flashloader.bin
  AfterMake: python ..\..\..\..\bin\create_fl_image_mdk.py output\debug\flashloader.elf flashloader.bin output\debug\flashloader_image.c
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: DEBUG, NDEBUG, USB_STACK_BM, CPU_MKL82Z128VMC7, CPU_IS_ARM_CORTEX_M0P=1, BL_TARGET_RAM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66,1296,186,170
  c include: ../../src;../../src/startup;../../../../src/platform/devices/MKL82Z7;../../../../src/autobaud;../../../../src/usb/include;../../../../src/usb/osa;../../../../src/usb/device;../../../../src/usb/device/class;../../../../src/bm_usb;../../../../src/include;../../../../src/platform;../../../../src/platform/devices;../../../../src/platform/CMSIS/Include;../../../../src;../../../../src/drivers;../../../../src/startup;../../../../src/drivers/common
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffa000 size 0x18000
  scatter file: ../../../common/linker/arm/MKL82Z7/MKL82Z128xxx7_ram_flashloader.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../common/linker/arm/MKL82Z7/: MKL82Z128xxx7_ram_flashloader.scf
  group src:startup
    ../../src/startup/arm/: startup_MKL82Z7.s
    ../../src/startup/: system_MKL82Z7.c
    ../../../../src/startup/: startup.c
  group MKL82Z7
    ../../src/: bootloader_config.h clock_config_MKL82Z7.c hardware_init_MKL82Z7.c memory_map_MKL82Z7.c external_memory_property_map_MKL82Z7.c peripherals_MKL82Z7.c peripherals_pinmux.h target_config.h bl_dspi_irq_config_MKL82Z7.c bl_i2c_irq_config_MKL82Z7.c bl_lpuart_irq_config_MKL82Z7.c
    ../../../common/src/: pinmux_utility_common.c bl_intmux_irq.c
  group src:autobaud:src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src:bootloader
    ../../../../src/bootloader/: bl_app_crc_check.h bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h
  group src:bootloader:src
    ../../../../src/bootloader/src/: lpuart_peripheral_interface.c dspi_peripheral_interface.c i2c_peripheral_interface.c usb_hid_msc_peripheral_interface.c bl_app_crc_check.c bl_misc.c bl_reliable_update.c bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c
  group src:drivers:crc
    ../../../../src/drivers/crc/: fsl_crc.c
  group src:drivers:microseconds:src
    ../../../../src/drivers/microseconds/src/: microseconds_pit.c
  group src:drivers:intmux
    ../../../../src/drivers/intmux/: fsl_intmux.c
  group src:drivers:lpuart
    ../../../../src/drivers/lpuart/: fsl_lpuart.c
  group src:drivers:i2c:src
    ../../../../src/drivers/i2c/: fsl_i2c.c
  group src:drivers:dspi
    ../../../../src/drivers/dspi/: fsl_dspi.c
  group src:drivers:qspi
    ../../../../src/drivers/qspi/: qspi.h
  group src:drivers:qspi:src
    ../../../../src/drivers/qspi/src/: qspi.c
  group src:drivers:ltc
    ../../../../src/drivers/ltc/: ltc.h
  group src:drivers:ltc:src
    ../../../../src/drivers/ltc/src/: ltc_aes_functions.c
  group src:usb:device:calss
    ../../../../src/usb/device/class/: usb_device_class.h usb_device_class.c usb_device_hid.h usb_device_hid.c usb_device_msc.h usb_device_msc.c usb_device_msc_ufi.h usb_device_msc_ufi.c
  group src:usb:device
    ../../../../src/usb/device/: usb_device.h usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_khci.c usb_device_khci.h
  group src:usb:include
    ../../../../src/usb/include/: usb.h
  group src:usb:osa
    ../../../../src/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group src:usb:bm_composite
    ../../../../src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c msc_disk.h msc_disk.c usb_descriptor.h usb_descriptor.c
    ../../src/: usb_device_config.h
  group src:memory:src
    ../../../../src/memory/src/: qspi_memory.c qspi_memory.h sram_init_cm0plus.c memory.c device_memory.h device_memory.c flash_memory.h flash_memory.c normal_memory.h normal_memory.c pattern_fill.h pattern_fill.s
  group src:security
    ../../../../src/security/: aes_security.h aes128_key_wrap_unwrap.h cbc_mac.h
  group src:security:src
    ../../../../src/security/src/: aes_security.c aes128_key_wrap_unwrap.c cbc_mac.c
  group src:autobaud
    ../../../../src/autobaud/: autobaud.h
  group src:crc
    ../../../../src/crc/: crc16.h crc32.h
  group src:crc:src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src:drivers:port
    ../../../../src/drivers/port/: fsl_port.h
  group src:drivers:gpio
    ../../../../src/drivers/gpio/: fsl_gpio.c
  group src:drivers:smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group src:drivers:flash
    ../../../../src/drivers/flash/: fsl_flash.c fsl_flash.h
  group src:drivers:microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src:include
    ../../../../src/include/: bootloader_common.h
  group src:memory
    ../../../../src/memory/: memory.h
  group src:packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src:packet:src
    ../../../../src/packet/src/: serial_packet.c
  group src:property
    ../../../../src/property/: property.h
  group src:property:src
    ../../../../src/property/src/: property.c
  group src:sbloader
    ../../../../src/sbloader/: sbloader.h
  group src:sbloader:src
    ../../../../src/sbloader/src/: sbloader.c
  group src:utilities
    ../../../../src/utilities/: fsl_rtos_abstraction.h
  group src:utilities:src
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
target flashloader Release (ARM-ADS)
  device: MKL82Z128xxx7 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: as above
  output: flashloader.elf
  AfterMake: fromelf  --bincombined output\release\flashloader.elf --output flashloader.bin
  AfterMake: python ..\..\..\..\bin\create_fl_image_mdk.py output\release\flashloader.elf flashloader.bin output\release\flashloader_image.c
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, USB_STACK_BM, CPU_MKL82Z128VMC7, CPU_IS_ARM_CORTEX_M0P=1, BL_TARGET_RAM
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffa000 size 0x18000
  scatter file: as above
  link misc: as above
