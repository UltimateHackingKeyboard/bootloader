# Keil uVision project freedom_bootloader.uvprojx, settings and files
target freedom_bootloader Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freedom_bootloader.elf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: DEBUG, NDEBUG, USB_STACK_BM, CPU_MKL25Z128VLK4, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, BL_TARGET_FLASH
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66,1296,186,170
  c include: ../../src;../../src/startup;../../../../src/platform/devices/MKL25Z4;../../../../src/autobaud;../../../../src/usb/include;../../../../src/usb/osa;../../../../src/usb/device;../../../../src/usb/device/class;../../../../src/bm_usb;../../../../src/include;../../../../src/platform;../../../../src/platform/devices;../../../../src/platform/CMSIS/Include;../../../../src;../../../../src/drivers;../../../../src/startup;../../../../src/drivers/common
  asm define: DEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ../../../common/linker/arm/MKL25Z4/MKL25Z128xxx4_application_0x0000.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__ram_vector_table__=1"
  group link
    ../../../common/linker/arm/MKL25Z4/: MKL25Z128xxx4_application_0x0000.scf
  group src:startup
    ../../src/startup/arm/: startup_MKL25Z4.s
    ../../src/startup/: system_MKL25Z4.c
    ../../../../src/startup/: startup.c
  group kl25z4
    ../../src/: bootloader_config.h clock_config_MKL25Z4.c hardware_init_MKL25Z4.c memory_map_MKL25Z4.c peripherals_MKL25Z4.c peripherals_pinmux.h target_config.h
    ../../../common/src/: pinmux_utility_common.c bl_i2c_irq_config_common.c
  group src:autobaud:src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src:bootloader:src
    ../../../../src/bootloader/src/: uart0_peripheral_interface.c spi_peripheral_interface.c i2c_peripheral_interface.c usb_hid_msc_peripheral_interface.c bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c
  group src:drivers:microseconds:src
    ../../../../src/drivers/microseconds/src/: microseconds_pit.c
  group src:drivers:systick
    ../../../../src/drivers/systick/: systick.h
  group src:drivers:systick:src
    ../../../../src/drivers/systick/src/: systick.c
  group src:drivers:watchdog
    ../../../../src/drivers/watchdog/: fsl_watchdog.h
  group src:drivers:watchdog:src
    ../../../../src/drivers/watchdog/src/: fsl_watchdog_cop.c
  group src:drivers:lpsci
    ../../../../src/drivers/lpsci/: fsl_lpsci.c
  group src:drivers:i2c:src
    ../../../../src/drivers/i2c/: fsl_i2c.c
  group src:drivers:spi
    ../../../../src/drivers/spi/: fsl_spi.c
  group src:usb:device:calss
    ../../../../src/usb/device/class/: usb_device_class.h usb_device_class.c usb_device_hid.h usb_device_hid.c usb_device_msc.h usb_device_msc.c usb_device_msc_ufi.h usb_device_msc_ufi.c
  group src:usb:device
    ../../../../src/usb/device/: usb_device.h usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_khci.c usb_device_khci.h
  group src:usb:include
    ../../../../src/usb/include/: usb.h
  group src:usb:osa
    ../../../../src/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group src:usb:bm_composite
    ../../../../src/bm_usb/: bootloader_hid_report_ids.h fat_directory_entry.h composite.h composite.c hid_bootloader.h hid_bootloader.c msc_disk.h msc_disk.c usb_descriptor.h usb_descriptor.c
    ../../src/: usb_device_config.h
  group src:memory:src
    ../../../../src/memory/src/: sram_init_cm0plus.c memory.c device_memory.h device_memory.c flash_memory.h flash_memory.c normal_memory.h normal_memory.c pattern_fill.h pattern_fill.s
  group src:autobaud
    ../../../../src/autobaud/: autobaud.h
  group src:bootloader
    ../../../../src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h
  group src:crc
    ../../../../src/crc/: crc16.h crc32.h
  group src:crc:src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src:drivers:port
    ../../../../src/drivers/port/: fsl_port.h
  group src:drivers:gpio
    ../../../../src/drivers/gpio/: fsl_gpio.c
  group src:drivers:smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group src:drivers:flash
    ../../../../src/drivers/flash/: fsl_flash.c fsl_flash.h
  group src:drivers:microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src:include
    ../../../../src/include/: bootloader_common.h
  group src:memory
    ../../../../src/memory/: memory.h
  group src:packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src:packet:src
    ../../../../src/packet/src/: serial_packet.c
  group src:property
    ../../../../src/property/: property.h
  group src:property:src
    ../../../../src/property/src/: property.c
  group src:sbloader
    ../../../../src/sbloader/: sbloader.h
  group src:sbloader:src
    ../../../../src/sbloader/src/: sbloader.c
  group src:utilities
    ../../../../src/utilities/: fsl_rtos_abstraction.h
  group src:utilities:src
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
target freedom_bootloader Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.8.0
  cpu: as above
  output: freedom_bootloader.elf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, USB_STACK_BM, CPU_MKL25Z128VLK4, CPU_IS_ARM_CORTEX_M0P=1, FREEDOM, BL_TARGET_FLASH
  c misc: as above
  c include: as above
  asm define: NDEBUG, BL_HAS_BOOTLOADER_CONFIG=0
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: as above
  link misc: as above
