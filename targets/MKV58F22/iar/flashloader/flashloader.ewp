# IAR project flashloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx22 Freescale MKV58F1M0xxx22
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; NDEBUG; CPU_MKV58F1M0VLQ22; CPU_IS_ARM_CORTEX_M7=1; IAR; BL_TARGET_RAM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../src; ../../src/startup; ../../../../src/platform/devices/MKV58F22; ../../../../src/autobaud; ../../../../src/include; ../../../../src/platform; ../../../../src/platform/devices; ../../../../src/platform/CMSIS/Include; ../../../../src; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  postbuild: cmd /c ..\..\..\..\bin\create_flashloader_image.bat $PROJ_DIR$ Debug
  ILINK.IlinkOutputFile: flashloader.elf
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MKV58F22/KV58F1M0xxx22_ram_flashloader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV58F1M0VLQ22; CPU_IS_ARM_CORTEX_M7=1; IAR; BL_TARGET_RAM
  AARM.ADefines: NDEBUG
  postbuild: cmd /c ..\..\..\..\bin\create_flashloader_image.bat $PROJ_DIR$ Release
  group link
    ../../../common/linker/iar/MKV58F22/: KV58F1M0xxx22_ram_flashloader.icf
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../src/startup/iar/: startup_MKV58F22.s
    ../../src/startup/: system_MKV58F22.c
  group src/autobaud
    ../../../../src/autobaud/: autobaud.h
  group src/autobaud/src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src/bootloader
    ../../../../src/bootloader/: bl_app_crc_check.h bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h bl_command.h bl_context.h bl_peripheral.h bl_shutdown_cleanup.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: scuart_peripheral_interface.c dspi_peripheral_interface.c i2c_peripheral_interface.c flexcan_peripheral_interface.c bl_app_crc_check.c bl_misc.c bl_reliable_update.c bl_user_entry.c bl_main.c bl_context.c bl_exception_handler.c bl_tree_root.c bl_command.c bl_shutdown_cleanup.c
  group src/drivers/crc
    ../../../../src/drivers/crc/: fsl_crc.c
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_pit.c
  group src/drivers/uart
    ../../../../src/drivers/uart/: fsl_uart.c
  group src/drivers/i2c/src
    ../../../../src/drivers/i2c/: fsl_i2c.c
  group src/drivers/dspi
    ../../../../src/drivers/dspi/: fsl_dspi.c
  group src/drivers/flexcan
    ../../../../src/drivers/flexcan/: fsl_flexcan.c
  group src/drivers/mmcau
    ../../../../src/drivers/mmcau/: mmcau.h
  group src/drivers/mmcau/src
    ../../../../src/drivers/mmcau/src/: mmcau_aes_functions.c
  group src/drivers/port
    ../../../../src/drivers/port/: fsl_port.h
  group src/drivers/gpio
    ../../../../src/drivers/gpio/: fsl_gpio.c
  group src/drivers/smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group src/drivers/flash
    ../../../../src/drivers/flash/: fsl_flash.c fsl_flash.h
  group src/memory
    ../../../../src/memory/: memory.h
  group src/memory/src
    ../../../../src/memory/src/: sram_init_cm7.c memory.c device_memory.h device_memory.c flash_memory.h flash_memory.c normal_memory.h normal_memory.c pattern_fill.h pattern_fill.s
  group src/security
    ../../../../src/security/: aes_security.h aes128_key_wrap_unwrap.h cbc_mac.h
  group src/security/src
    ../../../../src/security/src/: aes_security.c aes128_key_wrap_unwrap.c cbc_mac.c
  group src/crc
    ../../../../src/crc/: crc16.h crc32.h
  group src/crc/src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src/include
    ../../../../src/include/: bootloader_common.h
  group src/packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src/packet/src
    ../../../../src/packet/src/: serial_packet.c
  group src/property
    ../../../../src/property/: property.h
  group src/property/src
    ../../../../src/property/src/: property.c
  group src/sbloader
    ../../../../src/sbloader/: sbloader.h
  group src/sbloader/src
    ../../../../src/sbloader/src/: sbloader.c
  group src/utilities
    ../../../../src/utilities/: fsl_rtos_abstraction.h
  group src/utilities/src
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
  group kv58f22
    ../../src/: bootloader_config.h clock_config_kv58f22.c hardware_init_kv58f22.c memory_map_kv58f22.c peripherals_kv58f22.c peripherals_pinmux.h target_config.h
    ../../../common/src/: pinmux_utility_common.c bl_i2c_irq_config_common.c bl_dspi_irq_config_common.c bl_uart_irq_config_common.c
