# IAR project flashloader_loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx22 Freescale MKV58F1M0xxx22
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ22; CPU_IS_ARM_CORTEX_M7=1; IAR; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../flashloader/output; ../../src; ../../src/startup; ../../../../src/platform/devices/MKV58F22; ../../../../src/include; ../../../../src/platform/devices; ../../../../src/platform/CMSIS/Include; ../../../../src; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LITE_FOOTPRINT
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: flashloader_loader.elf
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MKV58F22/KV58F1M0xxx22_flashloader_loader.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKV58F1M0VLQ22; CPU_IS_ARM_CORTEX_M7=1; IAR; BL_TARGET_FLASH
  group link
    ../../../common/linker/iar/MKV58F22/: KV58F1M0xxx22_flashloader_loader.icf
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../src/startup/iar/: startup_MKV58F22.s
    ../../src/startup/: system_MKV58F22.c
  group src/bootloader
    ../../../../src/bootloader/: flashloader_image.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: bl_flashloader.c
  group src/include
    ../../../../src/include/: bootloader_common.h
  group kv58f22
    ../../src/: bootloader_config.h
