# Keil uVision project flashloader_loader.uvprojx, settings and files
target flashloader_loader Debug (ARM-ADS)
  device: MKV58F1M0xxx22 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.5.0
  cpu: IROM(0x10000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x2F000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: flashloader_loader.elf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV58F1M0VLQ22, CPU_IS_ARM_CORTEX_M7=1, BL_TARGET_FLASH
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
--diag_suppress=66,1296,186,170,2748
  c include: ../flashloader/output;../../src;../../src/startup;../../../../src/platform/devices/MKV58F22;../../../../src/include;../../../../src/platform/devices;../../../../src/platform/CMSIS/Include;../../../../src;../../../../src/drivers;../../../../src/startup;../../../../src/drivers/common
  asm define: BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x2f000000 size 0x10000
  scatter file: ../../../common/linker/arm/MKV58F22/MKV58F1M0xxx22_flashloader_loader.scf
  link misc: --remove 
--datacompressor 
off 
--feedback_type=unused,noiw 
--predefine="-D__stack_size__=0x200" 
--predefine="-D__heap_size__=0x200"
  group link
    ../../../common/linker/arm/MKV58F22/: MKV58F1M0xxx22_flashloader_loader.scf
  group src:startup
    ../../src/startup/arm/: startup_MKV58F22.s
    ../../src/startup/: system_MKV58F22.c
    ../../../../src/startup/: startup.c
  group kv58f22
    ../../src/: bootloader_config.h
  group src:bootloader
    ../../../../src/bootloader/: flashloader_image.h
  group src:bootloader:src
    ../../../../src/bootloader/src/: bl_flashloader.c
  group src:include
    ../../../../src/include/: bootloader_common.h
target flashloader_loader Release (ARM-ADS)
  device: MKV58F1M0xxx22 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.5.0
  cpu: as above
  output: flashloader_loader.elf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CPU_MKV58F1M0VLQ22, CPU_IS_ARM_CORTEX_M7=1, BL_TARGET_FLASH
  c misc: as above
  c include: as above
  asm define: BL_HAS_BOOTLOADER_CONFIG=0, LITE_FOOTPRINT
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../src/include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x2f000000 size 0x10000
  scatter file: as above
  link misc: as above
