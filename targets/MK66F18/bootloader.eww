<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>flashloader_loader</project><configuration>Release</configuration></member><member><project>flashloader_loader</project><configuration>Debug</configuration></member><member><project>freedom_bootloader</project><configuration>Debug</configuration></member><member><project>freedom_bootloader</project><configuration>Release</configuration></member><member><project>flashloader</project><configuration>Debug</configuration></member><member><project>flashloader</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>flashloader_loader</project><configuration>Release</configuration></member><member><project>freedom_bootloader</project><configuration>Release</configuration></member><member><project>flashloader</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>flashloader_loader</project><configuration>Debug</configuration></member><member><project>freedom_bootloader</project><configuration>Debug</configuration></member><member><project>flashloader</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/iar/flashloader_loader/flashloader_loader.ewp</path></project><project><path>$WS_DIR$/iar/freedom_bootloader/freedom_bootloader.ewp</path></project><project><path>$WS_DIR$/iar/flashloader/flashloader.ewp</path></project></workspace>
